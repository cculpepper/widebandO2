# Keil uVision project widebando2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK64FX512xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x20000) IRAM(0x20000000,0x20000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: widebando2
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: adc.c adc.h common.h dac.c dac.h delay.c delay.h gpio.h i2c.c i2c.h main.c PID.c PID.h PIT.c PIT.h pwm.c pwm.h queue.c queue.h sin.c sin.h uart.c uart.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
